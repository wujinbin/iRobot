# Keil uVision project template.uvproj, settings and files
target iRobot (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\motor;..\SYSTEM\adc;..\SYSTEM\dma;..\SYSTEM\irq;..\HARDWARE\sensor
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/adc/: ADC.c
    ../SYSTEM/dma/: dma.c
    ../SYSTEM/irq/: irq.c
  group HARDWARE
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/sensor/: sensor.c
